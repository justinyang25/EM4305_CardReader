# Keil uVision project EM4305Card_ReadWrite.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: EM4305Card_ReadWrite +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Header
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/: Uart.c CopyEM4100.c EM41xx.c EMReadWriteCard.c mian.c T5557.c CRC16.c
  group Header
    ./Header/: Uart.h CopyEM4100.h EM41xx.h EMReadWriteCard.h IntPut_IO.h STC8F.h T5557.h
  group Text
    ./Text/: Read.txt
